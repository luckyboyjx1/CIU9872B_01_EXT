# Keil uVision project MH1701.uvproj, settings and files
target MH1701 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MH1701 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STD_IO_PORT = STD_IO_PORT_GPIO
  c misc: --feedback=Objects\MH_1701_FB.txt
  c include: .;src\BootLoader;src\Boot;src\Boot\Apdu;src\Boot\Apdu\Io;src\Boot\Apdu\Io\7816Channel;src\Boot\Apdu\Io\7816Util;src\Boot\Apdu\Io\Io_14443Ta;src\Boot\Apdu\Io\Io_7816T0;src\Boot\Apdu\Io\Io_7816T1;src\Boot\Apdu\Io\Io_Swp;src\Boot\Apdu\Io\Io_Uart;src\Boot\Apdu\Io\MixMode;src\Boot\Apdu\Io\Wtx;src\Boot\Crypto;src\Boot\Crypto\HMAC;src\Boot\ErrorHandle;src\Boot\lib;src\Boot\LifeCycle;src\Boot\Memory;src\Boot\Memory\MemFunction;src\Boot\Mifare;src\Boot\NvmManager;src\Boot\Patch;src\Boot\RamManager;src\Boot\SecureOperation;configFile\common\bootConfigFile;configFile\common\halConfigFile;configFile\common\vmConfigFile;src\Hal\CryptoHal;src\Hal\CryptoHal\CryptoLib;src\Hal\DataOperation;src\Hal\IoHal;src\Hal\MifareHal;src\Hal\NvmHal;src\Hal\PatchHal;src\Hal\SecOperationHal;src\Hal\SystemConfig;src\Hal\SystemConfig\SysHal;src\Jcvm;src\Jcvm\AbroadLteGp;src\Jcvm\chnmanager;src\Jcvm\dataManager;src\Jcvm\head;src\Jcvm\Init;src\Jcvm\keyManager;src\Jcvm\memory;src\Jcvm\NativeAppAPI;src\Jcvm\openplatform;src\Jcvm\optspace;src\Jcvm\roomManager;src\Jcvm\SCP;src\Jcvm\transient;src\Jcvm\VM;src\Jcvm\VM_JavaCard305;src\SimHal;src\SimHal\CryptoLib;src\SimHal\Patch;.\src\Boot\Apdu\Io\Io_SPI;.\src\Boot\Apdu\Io\Io_I2C;.\src\Interface;.\configFile\platform\chipCfg\bootConfigFile;.\configFile\platform\chipCfg\halConfigFile;.\configFile\platform\chipCfg\vmConfigFile;.\src\gw;.\ChipProjectFile;.\src\Boot\Apdu\Io\Io_Protocol;.\src\UiccFunction;.\src\UiccFunction\BIP;.\src\UiccFunction\GpAnnexB;.\src\UiccFunction\TimerModule;.\src\UiccFunction\UiccInterface;.\src\UiccFunction\uiccJava;.\src\UiccFunction\uiccJava\CATTP;.\src\UiccFunction\uiccJava\CDMA;.\src\UiccFunction\uiccJava\CoreAlgorithm;.\src\UiccFunction\uiccJava\CSIMAPI;.\src\UiccFunction\uiccJava\EUICCManage;.\src\UiccFunction\uiccJava\PEManage;.\src\UiccFunction\uiccJava\RemoteMange;.\src\UpCosOnlineMutual;.\src\UiccFunction\DNS;.\src\Hal\CryptoHal\CryptoLib\secp256r1;.\src\Hal\CryptoHal\CryptoLib\x25519;.\ChipProjectFile\MH1701_HAL\Include;.\ChipProjectFile\MH1701_HAL\MHSCPU_DRiver\inc;.\ChipProjectFile\MH1701_HAL\MHSCPU_DRiver\inc\cryptlib
  library: MicroLIB
  memory RVCT4: ROM 0x801000 size 0x7f000
  memory RVCT9: RAM 0x20000800 size 0x1f80
  scatter file: .\ChipProjectFile_sct\MH1701.sct
  link misc: --remove
--feedback=Objects\MH_1701_FB.txt


--keep haldataconfig.o(sysConfigDataArea)

--keep chipDataConfig.o(chipConfigDataArea)

--keep JcvmDataConfig.o(vmConfigDataArea)

--keep opFunction.o(ER_GetConfigBase)

--keep SCPInteface.o(scpDataArea)

--keep SysHal.o(seInfoDataArea)

--keep SysHal.o(CRCDataArea)
--keep *.o(LogicBakDataArea)
  group main
    src/JcvmMain/: main.c
    ./ChipProjectFile/: app_main.c os_main.c
  group Startup
    ./ChipProjectFile/: startup_mhscpu.s system_mhcard.c
  group ConfigFile
    configFile/common/bootConfigFile/: appHeader.h BootAreaInitRam.h bootConfigMethod.c bootConfigMethod.h bootConfigProfile.h BootNoAreaInitRam.h BootRam.h cryptoProfile.h
    configFile/common/halConfigFile/: halCryptoConfig.h halCryptoProfile.h halDataConfig.c swpDataConfig.c swpDataConfig.h SysConfigHalRam.h SysConfigProfile.h SysConfigTarget.h
    configFile/common/vmConfigFile/: jcvmConfigMethod.c jcvmConfigMethod.h JcvmDataConfig.c JcvmDataConfig.h JcvmRam.h mask.c mask.h profile.h target.h
    ./configFile/common/vmConfigFile/: euiccConfig.c euiccConfig.h
    ./configFile/platform/chipCfg/bootConfigFile/: bootPlaformConfigProfile.h
    ./configFile/platform/chipCfg/halConfigFile/: chipHead.h SysPlatformConfigProfile.h
    ./configFile/platform/chipCfg/vmConfigFile/: JcvmPlatformProfile.h
  group Chip_HAL
    ./ChipProjectFile/: chipDataConfig.c chipDataConfig.h CreateJavaBuffer.c ChipCoreFunction.c ChipCoreFunction.h ChipFunction.c ChipFunction.h interrupt.c
    ./configFile/platform/chipCfg/halConfigFile/: chipHead.h
    ./ChipProjectFile/MH1701_HAL/MHSCPU_DRiver/src/: mhcard_flash.c mhcard_iso7816.c mhcard_sysctrl.c mhcard_timer.c misc.c mhcard_stdio.c
  group Chip_Lib
    ./ChipProjectFile/MH1701_HAL/MHSCPU_DRiver/lib/: mh_security_api.lib mh_security_api_EN_out.lib mh_crypt_lib.lib
    ./ChipProjectFile/MH1701_HAL/MHSCPU_DRiver/inc/cryptlib/: mh_aes.h mh_bignum.h mh_crypt.h mh_des.h mh_ecc.h mh_eccpoint.h mh_rand.h mh_sha.h mh_smrand.h
    ./ChipProjectFile/MH1701_HAL/MHSCPU_DRiver/inc/: mhcard_crc.h
  group BootLoader
    ./src/BootLoader/: FunEntryConfig.c FunEntryConfig.h FunImp.c FunImp.h BL_Upgrade.h
    src/Boot/: BootOSImpl.h
  group Boot
    src/Boot/: Boot.c Boot.h BootOS.c BootOS.h BootOSImpl.c BootRegister.c BootRegister.h
  group Boot_Apdu
    src/Boot/Apdu/: Apdu.c Apdu.h
    src/Boot/Apdu/Io/7816Channel/: 7816Channel.c 7816Channel.h
    src/Boot/Apdu/Io/7816Util/: 7816Util.c 7816Util.h IoBuffer.c IoBuffer.h
    src/Boot/Apdu/Io/Io_7816T0/: Io_7816T0.c Io_7816T0.h
    src/Boot/Apdu/Io/Io_7816T1/: Io_7816T1.c Io_7816T1.h
    src/Boot/Apdu/Io/Io_14443Ta/: Io_14443TaL3.c Io_14443TaL3.h Io_14443TaL4.c Io_14443TaL4.h
    src/Boot/Apdu/Io/Wtx/: WtxInterupt.c WtxInterupt.h WtxTimer.c WtxTimer.h
    src/Boot/Apdu/Io/: Io.c Io.h
    src/Boot/Apdu/Io/Io_Uart/: Io_Uart.c Io_Uart.h
    src/Boot/Apdu/Io/MixMode/: MixMode.c MixMode.h
    ./src/Boot/Apdu/Io/Io_SPI/: Io_SPI.c Io_SPI.h
    ./src/Boot/Apdu/Io/Io_I2C/: Io_I2C.c Io_I2C.h
    ./src/Boot/Apdu/Io/: Io_interface.c Io_interface.h
    ./src/Boot/Apdu/Io/Io_Protocol/: Io_Protocol.c Io_Protocol.h
    ./src/Boot/Apdu/Io/Io_Swp/: Io_Swp.c Swp_Hci_Api.c
  group Boot_Crypto
    src/Boot/Crypto/EllipseCurve/: EllipseCurve_API.c
    src/Boot/Crypto/HASH/: HASH_API.c
    src/Boot/Crypto/HMAC/: HMAC_API.c HMAC_API.h
    src/Boot/Crypto/RSA/: RSA_API.c
    src/Boot/Crypto/Sym/: Sym_API.c
    src/Boot/Crypto/: Crypto_API.h Crypto_API.c
  group Boot_ErrorHandle
    src/Boot/ErrorHandle/: BootErrorHandle.c BootErrorHandle.h
  group Boot_Lib
    src/Boot/lib/: FreeTable.c FreeTable.h FreeTableResize.c FreeTableResize.h
  group Boot_LifeCycle
    src/Boot/LifeCycle/: BootLifeCycle.c BootLifeCycle.h
  group Boot_Memory
    src/Boot/Memory/MemFunction/: MemBackUpServe.c MemBackUpServe.h MemNvmOperation.c MemNvmOperation.h MemOperationServe.c MemOperationServe.h
    src/Boot/Memory/: FlashBackUp.c FlashBackUp.h MemBackUp.c MemBackUp.h MemGetReuseRam.c MemGetReuseRam.h MemOperation.c MemOperation.h
    ./src/Boot/Memory/: MemBackUpPageB.c FlashBackUpPageB.c
    ./src/Boot/Memory/MemFunction/: MemBackUpServePageB.c
  group Boot_Mifare
    src/Boot/Mifare/: Mifare.c Mifare.h
  group Boot_NvmManager
    src/Boot/NvmManager/: NvmAllocate.c NvmAllocate.h NvmCompact.c NvmCompact.h NvmDeallocate.c NvmDeallocate.h NvmManager.c NvmManager.h NvmMap.c NvmMap.h NvmResize.c NvmResize.h
  group Boot_Patch
    src/Boot/Patch/: Patch.c Patch.h
  group Boot_RamManager
    src/Boot/RamManager/: RamManager.c RamManager.h
  group Boot_SecureOperation
    src/Boot/SecureOperation/: SecureCrypto.c SecureCrypto.h SecureOperation.c SecureOperation.h
    ./src/Boot/SecureOperation/: SensiTiveResult.c
  group Hal_CryptoHal
    src/Hal/CryptoHal/: CRC_API.h Crypto_common_API.h Crypto_Constant.h EllipseCurve_API.h HASH_API.h RNG_API.h RSA_API.h Sym_API.h
    src/Hal/CryptoHal/common/: Crypto_common_API.c
    src/Hal/CryptoHal/CRC/: CRC_HAL.c
    src/Hal/CryptoHal/CryptoLib/: Crypto_SoftAES.c Crypto_SoftAES.h Crypto_softCRC.c Crypto_softCRC.h Crypto_SoftDES.c Crypto_SoftDES.h Crypto_softKOREANSEED.c Crypto_softKOREANSEED.h Crypto_softMD.c Crypto_SoftMD.h Crypto_softSHA1.c Crypto_SoftSHA1.h Crypto_softSHA224.c Crypto_SoftSHA224.h Crypto_softSHA256.c Crypto_SoftSHA256.h Crypto_softSHA384.c Crypto_SoftSHA384.h Crypto_softSHA512.c Crypto_SoftSHA512.h Crypto_SoftSM3.c Crypto_SoftSM3.h Crypto_SoftSM4.c Crypto_SoftSM4.h
    src/Hal/CryptoHal/EllipseCurve/: EllipseCurve_HAL.c
    src/Hal/CryptoHal/HASH/: HASH_MD_HAL.c HASH_RIPEMD160_HAL.c HASH_SHA1_HAL.c HASH_SHA224_HAL.c HASH_SHA256_HAL.c HASH_SHA384_HAL.c HASH_SHA512_HAL.c HASH_SM3_HAL.c
    src/Hal/CryptoHal/RNG/: RNG_HAL.c
    src/Hal/CryptoHal/RSA/: RSA_HAL.c
    src/Hal/CryptoHal/Sym/: Sym_AES_HAL.c Sym_DES_HAL.c Sym_KOREANSEED_HAL.c Sym_SM1_HAL.c Sym_SM4_HAL.c Sym_SSF33_HAL.c
    ./src/Hal/CryptoHal/Sym/: Sym_SM7_HAL.c Sym_AEAD_HAL.c
    ./src/Hal/CryptoHal/: DH_HAL.c
    ./src/Hal/CryptoHal/CryptoLib/: Crypto_SoftAEAD.c
    ./src/Hal/CryptoHal/CryptoLib/x25519/: curve25519.c curve25519.h
  group Hal_DataOperationHal
    src/Hal/DataOperation/: DataOperation.h ecpDefine.c ecpDefine.h ecpOperation.c ecpOperation.h ecpReadWrite.h
  group Hal_IoHal
    src/Hal/IoHal/: RfHal.c RfHal.h SwpHal.c SwpHal.h SwpTimerHal.c SwpTimerHal.h UartHal.c UartHal.h WtxTimerHal.c WtxTimerHal.h
    ./src/Hal/IoHal/: SpiHal.c SpiHal.h I2cHal.c I2cHal.h
  group Hal_MifareHal
    src/Hal/MifareHal/: MifareHal.c MifareHal.h
  group Hal_NvmHal
    src/Hal/NvmHal/: NvmHal.c NvmHal.h
  group Hal_PatchHal
    src/Hal/PatchHal/: PatchHal.c PatchHal.h
  group Hal_SecOperationHal
    src/Hal/SecOperationHal/: SecOperationHal.c SecOperationHal.h
  group Hal_SystemConfig
    src/Hal/SystemConfig/: SysConfig.c SysConfig.h SysConfigData.h
    src/Hal/SystemConfig/SysHal/: SysHal.c SysHal.h
  group Jcvm_AbroadLteGp
    src/Jcvm/AbroadLteGp/: AbroadLteOp.c
  group Jcvm_Chnmanager
    src/Jcvm/chnmanager/: chn_manager.c
  group Jcvm_DataManager
    src/Jcvm/dataManager/: dataManager.c tagNode.c
  group Jcvm_Head
    src/Jcvm/head/: anomaly.h bc_arith.h bc_array.h bc_const.h bc_control.h bc_field.h bc_load.h bc_object.h bc_return.h bc_stack.h bc_static.h bc_store.h cardManager.h CASDNativeMethod.h casdStoreKey.h chn_manager.h clProtocol_global.h CLProtocolMngt.h contentManager.h context.h crypto_impl.h CVM.h dataManager.h error.h except.h firewall.h fm01_keyData.h fm02_keyData.h fm03_keyData.h gc.h global_variable.h grt.h interpreter.h Jcvm_Nvm.h keyData.h KeyExtData.h keyGroup.h KeyLogicManager.h KeyManager.h KeyManagerOld.h keySet.h lifecycle.h Loader.h mathNativeImpl.h method.h native_interface.h nativemethod_impl.h ob_manager.h object.h OPCMCal.h opcode.h opFunction.h OPInstaller.h optspace.h packageloc.h reference.h reset.h SCP01.h SCP02.h SCP03.h SCP10.h SCPAPINativeMethod.h SCPDealData.h SCPGenKeyInterface.h SCPInterface.h SCPParamCheck.h SecurityDomainData.h stack.h TableMgmntTypes.h tagNode.h temp_ob_manager.h typejava.h util_NM.h utilMethod.h
  group Jcvm_Init
    src/Jcvm/Init/: JcvmConfig.c JcvmConfig.h JcvmInit.c JcvmInit.h
  group Jcvm_KeyManager
    src/Jcvm/keyManager/: casdStoreKey.c fm01_keyData.c fm02_keyData.c fm03_KeyData.c keyData.c keyExtData.c keyGroup.c KeyLogicManager.c keyManager.c keySet.c
  group Jcvm_Memory
    src/Jcvm/memory/: global_variable.c Jcvm_Nvm.c memory.c memory.h
  group Jcvm_NativeAppApi
    src/Jcvm/NativeAppAPI/: AppAPI.c AppAPI.h AppEdepAPI.c AppEdepAPI.h AppEidAPI.c AppEidAPI.h LteAPI.c LteAPI.h NativeAppComponent.c NativeAppComponent.h PbocAPI.c PbocAPI.h
  group Jcvm_OpenPlatform
    src/Jcvm/openplatform/: cardManager.c CASDNativeMethod.c CLProtocolMngt.c contentManager.c CVM.c KeyManagerOld.c Loader.c OPCMCal.c opFunction.c OPInstaller.c securityDomainData.c utilMethod.c
    ./src/Jcvm/openplatform/: OPELFUpgrade.c
  group Jcvm_Optspace
    src/Jcvm/optspace/: opt_bc_arith.c opt_bc_array.c opt_bc_control.c opt_bc_load.c opt_bc_stack.c opt_bc_static.c opt_bc_store.c opt_firewall.c opt_MemOperation.c opt_method.c opt_nativemethod_impl.c opt_object.c optvm.c
  group Jcvm_RoomManager
    src/Jcvm/roomManager/: CgmDel.c CgmDel.h CgmField.c CgmField.h CgmInit.c CgmInit.h CgmInstall.c CgmInstall.h CgmLoad.c CgmLoad.h CgmManager.c CgmManager.h CgmRun.c CgmRun.h
  group Jcvm_SCP
    src/Jcvm/SCP/: SCP01.c SCP02.c SCP03.c SCP10.c SCPAPINativeMethod.c SCPDealData.c SCPGenKeyInterface.c SCPInteface.c SCPParamCheck.c
    ./src/Jcvm/SCP/: SCP11.c
  group Jcvm_Transient
    src/Jcvm/transient/: dtrSpace.c dtrSpace.h tranAllocate.c tranAllocate.h tranDeallocate.c tranDeallocate.h tranManager.c tranManager.h
    ./src/Jcvm/transient/: rtrSpace.c rtrSpace.h
  group Jcvm_VM
    src/Jcvm/VM/: bc_arith.c bc_array.c bc_const.c bc_control.c bc_field.c bc_load.c bc_object.c bc_return.c bc_stack.c bc_static.c bc_store.c context.c crypto_impl.c error.c except.c firewall.c gc_main.c grt.c interpreter.c lifecycle.c method.c native_interface.c nativemethod_impl.c ob_manager.c object.c packageloc.c reference.c reset.c stack.c temp_ob_manager.c
    ./src/Jcvm/: ASN1Operation.c EUICCCustomerCertificate.c
  group Jcvm_VM_JavaCard305
    ./src/Jcvm/VM_JavaCard305/: native_interface_JavaCard305.c nativemethod_impl_JavaCard305.c
  group Interface
    ./src/Interface/: Interface_Boot.c Interface_Boot.h Interface_eSEPrivateAPI.h Interface_LTEFromPlatform.c Interface_LTEFromPlatform.h Interface_PlatformFromLTE.c Interface_PlatformFromLTE.h SEEUICCInterface.c SEEUICCInterface.h uicc.h EUICCInterface.c
  group EUICC_EUICCManage
    ./src/UiccFunction/uiccJava/EUICCManage/: EUICCCustomer.c EUICCCustomer.h EUICCCustomerPublic.c EUICCCustomerPublic.h EUICCGPDataOpertion.c EUICCGPDataOpertion.h EUICCM2MAPDU.c EUICCM2MAPDU.h EUICCM2MAPDUPublic.c EUICCM2MAPDUPublic.h EUICCMain.c EUICCMain.h EUICCPersonalAPDU.c EUICCPersonalAPDU.h EUICCProfile.c EUICCProfile.h EUICCRAM.c EUICCRAM.h ProfileAPI.c ProfileGPCommand.c ProfileGPCommand.h SCP03Realize.c SCP03Realize.h VMAccessEeprom.c VMAccessEeprom.h
  group EUICC_PEManage
    ./src/UiccFunction/uiccJava/PEManage/: PEAKAParameter.c PEApplication.c PECDMAParameter.c PEEnd.c PEFileSystem.c PEGenericFileManagement.c PENonStandard.c PEPinCodes.c PEPukCodes.c PERFM.c PESecurityDomain.c PETemplateFileProcess.c PETemplateFileProcess.h profileApi.h ProfileHeader.c ProfileInterpreter.c ProfileInterpreter.h tlvHeader.h tlvOperation.c
  group Tele_UiccInterface
    ./src/UiccFunction/UiccInterface/: Interface_AnnexB.c Interface_AnnexB.h Interface_TimerModule.c Interface_TimerModule.h LiveWirteCardXL.c LiveWirteCardXL.h STK_App .c UploadInfoFunction.c UploadInfoFunction.h WhiteCardBeWrited.h WhiteCardBeWrited_V1.c Interface_DNS.c
  group Tele_BIP
    ./src/UiccFunction/BIP/: BIPModuleProcess.c BIPModuleProcess.h
  group Tele_GpAnnexB
    ./src/UiccFunction/GpAnnexB/: Exception.h GPAnnexbAdminSessionPara.c GPAnnexbAdminSessionPara.h GPSCP81KeyManagement.h HttpProcess.c HttpProcess.h Scp81Connection.c Scp81Connection.h TlsAlgorithm.c TlsAlgorithm.h TlsMainFlow.c TlsMainFlow.h
  group Tele_TimerModule
    ./src/UiccFunction/TimerModule/: TimerModuleProces.c TimerModuleProces.h
  group Tele_uicc
    ./src/UiccFunction/uiccJava/: a3a8.c arithmatic.c arithmatic.h Authentication.c Authentication.h catfunction.c ceph.c ceph.h ChinaMobileRedTea.c ChinaMobileRedTea.h CMCCAPIImpl.c CMCCAPIImpl.h CreatFile.c DataOrientedCommand.c DataOrientedCommand.h exteralcommand.c fileAction.c fileAction.h filesystem.h FunctionSwitch.h gsmChvManagement.c gsmfuction.c gsmpublic.c gsmpublic.h hard_api.c hard_api.h interface.h Keccak.c Keccak.h LocalKey.c Mbms.c Mbms.h Milenage.c NativeEditHandler.c NativeEnvelopeHandler.c NativeEnvelopeResponseHandler.c NativeMEProfile.c NativeProactiveHanlder.c NativeProactiveResponseHandler.c NativeSimAccess.c NativeToolkitRegistry.c NativeViewHandler.c noFileShare.c platform_api.c platform_api.h PrivateCommand.c PrivateCommand.h public.c SimApi.h SIMToolkitConstant.h STKAlert.c stkalert.h STKCATRuntimeEnviorment.c STKCATRuntimeEnviorment.h STKFileView.c STKFileView.h stkhead.h STKNativeMethod.c STKNativeMethod.h STKRemoteAppManagement.c STKRemoteAppManagement.h stkSubFunction.c STKToolkitInterface.c STKToolkitInterface.h Supi.c Supi.h SuspendUicc.c SuspendUicc.h T0ApduImpl.c T0ApduImpl.h ToolkitAPIPublic.c ToolkitAPIPublic.h ToolkitRegisterypublic.c ToolkitRFM.c ToolkitRFM.h TransFormat.c TransFormat.h TUAK.c tuak.h typedef.h uicc_error.c uicc_error.h uicc_interface.c uicc_interface.h uicc_M2M.c uicc_M2M.h uicc_main.c uicc_main.h UICCAdminFileView.c UICCEditHandler.c UICCEnvelopHandler.c UICCEnvelopResponseHandler.c UICCFileView.c UICCProactiveHandler.c UICCProactiveResHandler.c UICCTerminalProfile.c UICCToolkitAPI.h UICCToolkitConstants.h UICCToolkitRegistery.c UICCViewHandler.c USATEnvelopeHandler.c USATEnvelopeHandler.h USATTest.c variable.c variable_tag.h XORAuthentication.c javaUiccAPI.c EapAuthentication.c EapAuthentication.h Prf.c
  group Tele_CATTP
    ./src/UiccFunction/uiccJava/CATTP/: CatTp.h CatTpFunction.c CatTpSubfunction.c Interface_CATTP.c Interface_CATTP.h
  group Tele_CDMA
    ./src/UiccFunction/uiccJava/CDMA/: cdma.h cdma2gsm.c cdmaAuth.c cdmabasefunction.c cdmabasesubfunction.c cdmaPRL.c new_cdma_md5_interface.c
  group Tele_CSIMAPI
    ./src/UiccFunction/uiccJava/CSIMAPI/: CSIMApiImpl.c CSIMApiImpl.h
  group Tele_RemoteMange
    ./src/UiccFunction/uiccJava/RemoteMange/: CBDownload.c CompactManage.c CompactManage.h ExpandedManage.c ExpandedManage.h
  group UpCosOnlineMutual
    ./src/UpCosOnlineMutual/: UpCos.c UpCos.h
  group DNS
    ./src/UiccFunction/DNS/: DNS.c
